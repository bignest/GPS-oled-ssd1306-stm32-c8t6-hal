# IAR project YS-F1Mini.ewp, settings and files
configuration YS-F1Mini (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ..\Inc\bsp; ..\Inc\nmea_decode\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: YS-F1Mini.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c nema_decode_test.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group bsp
    ../Src/bsp/usart/: bsp_debug_usart.c
    ../Src/bsp/gps/: bsp_gps_usartx.c
    ../Src/bsp/led/: bsp_led.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group nmealib
    ../Src/nmea_decode/src/: context.c generate.c generator.c gmath.c info.c parse.c parser.c sentence.c time.c tok.c
  group Readme
    ../Readme/: 01.例程功能说明.txt 02.开发环境说明.txt
